FILESEXTRAPATHS_append := ":${THISDIR}/files"
SRC_URI_remove = "file://run-bluetoothd-with-experimental-flag.patch"
