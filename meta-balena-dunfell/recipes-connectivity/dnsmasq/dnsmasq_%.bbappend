FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-SIOCGSTAMP-is-defined-in-linux-sockios.h-not-asm-soc.patch"

