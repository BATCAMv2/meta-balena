SRC_URI_remove = "file://initialize-direntry.patch"
